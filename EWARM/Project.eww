<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SMC_VZVES_053.ewp</path>
  </project>
  <batchBuild />
</workspace>
